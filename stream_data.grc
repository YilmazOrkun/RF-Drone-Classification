options:
  parameters:
    generate_options: qt_gui
    id: stream_data
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/cosmo/Downloads/archive/drone_rf_classification/dataset_replay.c64
    repeat: 'True'
    type: complex
    vlen: '128'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
    vlen: '128'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 1e6
    type: complex
    vlen: '128'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hann(128)
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    hwm: '1000'
    timeout: '100'
    type: complex
    vlen: '128'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
